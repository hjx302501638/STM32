# Keil uVision project STMFLASH.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STMFLASH +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\tans\Display;..\tans\Menu;..\mywrite\include;..\HARDWARE\ADC;..\tans\DS1302;..\tans\Voice
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/ADC/: my_adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c
  group README
    ../: README.TXT
  group mywrite
    ../mywrite/keyboard/: keyboard.c
    ../mywrite/Timer/: Timer.c
    ../mywrite/IO/: IO.c
    ../mywrite/flashmanege/: falshmanege.c
    ../mywrite/APP/: APP.c
  group tans
    ../tans/Display/: Dis12864.c
    ../tans/DS1302/: DS1302.c
    ../tans/Voice/: Voice.c
  group menu
    ../mywrite/Menu/: admin.c getwarte.c query.c useset.c menu.c
